# Repository Torimaru24/Pawn

## EAGLE design Pawn.brd

Parts:
C1, C4, C5, C6, C7, C8: 100nF; 2012-C
C2, C11: 1n; 2012-C
C3: 1uF; 2012-C
C9, C10: 4.7uF; 2012-C
C12: 10uF; 2012-C
C16: 22uF; 2012-C
C17, C31, C35: 0.1u; 2012-C
C32, C33: 22p; 1608
C34: 0.47u; 2012-C
CON2: MTDRV-A; 5251-05-A
CON4: D-3500-4; D3500D-4-HORIZONTAL
CON5, CON6: MOLEX-5251-03-A; 5251-03-A
CON7: MOLEX-5251-02-S_LONG; 5251-02-S_LONG
CON26: MINI-USB-; UX60A-MB-5ST
CON27: UART-S; IL-G-04-S
D2: LED-5; LED5
D3: LED-3; LED3
D4: GREEN; LED3
D5: RB160M-30TR; D3216
IC1: AZ1086H-3.3; SOT223
IC2: 7W14FU; MSOP8
IC8: R5F10JB; TQFP32-08
R1, R6: 1kΩ; 2012-R
R2, R3, R8, R9: 10k; 2012-R
R4, R5, R36: 1k; 2012-R
R34: 4.7k; 2012-R
R35: 22k; 2012-R
RESET1: CHECK_PIN; SLC-22-G
SW2: TOGGLESW
U$1: STM32F411RET6; ET-PCB-LQFP64
X2: 6/8/12/16MHz; HC49/S

Connections:
+3V3: C3.1, C4.1, C5.1, C6.1, C7.1, C8.1, C9.1, C16.1, C31.1, C35.1, CON2.5 (VCC), D3.A, IC1.OUT, IC1.VOUT (OUT), IC8.8 (VDD), IC8.21 (UVDD), R34.1, R35.1, U$1.P$13 (VDDA), U$1.P$19 (VDD_1), U$1.P$32 (VDD_2), U$1.P$48 (VDD_3), U$1.P$64 (VDD_4)
+5V: C12.1, CON4.B1, CON5.2, IC1.IN, IC2.8 (VCC), R2.1, R3.1, R8.1, SW2.2
DISTANCE: CON5.1, U$1.P$8 (PC0/ADC1_10)
ENC_A: IC2.7 (Y), U$1.P$55 (PB3/JTDO-SWO/TIM2_CH2/SPI1_SCK/I2S1_CK/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)
ENC_B: IC2.2 (Y), U$1.P$50 (PA15/JTDI/TIM2_CH1/TIM2_ETR/SPI1_NSS/I2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)
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, C16.2, C17.2, C31.2, C32.2, C33.2, C34.2, C35.2, CON2.4 (GND), CON4.A2, CON5.3, CON6.3, CON26.5, CON26.M1 (SHELL), CON27.1 (GND), IC1.GND, IC2.4 (GND), IC8.3 (P137/INTP0), IC8.7 (VSS), R1.2, R6.2, R36.2, U$1.P$12 (VSSA), U$1.P$18 (VSS_1), U$1.P$31 (VSS_2), U$1.P$47 (VSS_3), U$1.P$60 (BOOT0), U$1.P$63 (VSS_4)
JTCK: IC8.30 (P01/ANI16/TO00/INTP9/SCK01/SCL01/(SCLA0)), U$1.P$49 (PA14/JTCK-SWCLK)
JTMS: IC8.14 (P30/INTP3/SCK00/SCL00/(TI03)/(TO03)/(PC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), U$1.P$46 (PA13/JTMS-SWDIO)
LED1: D2.A, U$1.P$2 (PC13)
MD1_DIR1: CON2.2 (S), U$1.P$11 (PC3/SPI2_MOSI/I2S2_SD/ADC1_13)
MD1_PWM: CON2.1 (S), U$1.P$14 (PA0-WKUP/TIM2_CH1/TIM2_ET/TIM5_CH1/USAR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)
unnamed: D2.K, R6.1
unnamed: C10.1, U$1.P$30 (VCAP1)
unnamed: CON4.A1, R2.2, R4.1
unnamed: C2.1, IC2.1 (A), R4.2
unnamed: D3.K, R1.1
unnamed: C11.1, IC2.6 (A), R5.2
unnamed: CON4.B2, R3.2, R5.1
unnamed: CON6.1, R8.2, R9.1
unnamed: C17.1, IC2.3 (A), R9.2
unnamed: C1.1, U$1.P$7 (NRST)
unnamed: CON26.3, IC8.24 (UDP0)
unnamed: CON26.2, IC8.23 (UDM0)
unnamed: C32.1, IC8.4 (P122/X2/EXCLK), X2.1
unnamed: C33.1, IC8.5 (P121/X1), X2.2
unnamed: IC8.2 (!RESET!), R35.2, RESET1.SIGNAL
unnamed: C34.1, IC8.6 (REGC)
unnamed: CON27.3 (S), D5.A, IC8.1 (P40/TOOL0), R34.2
unnamed: CON27.2 (S), D5.K (C)
unnamed: D4.A, IC8.17 (P17/TI02/TO02/UVBUSEN1)
unnamed: D4.K, R36.1
POWER_FROM_USB: CON26.1, SW2.1 (O)
RX_FOR_STM: CON7.2, U$1.P$17 (PA3/TIM2_CH4/TIM5_CH4/TIM9_CH2/I2S2_MCK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)
SWITCH: IC2.5 (Y), U$1.P$58 (PB6/TIM4_CH1/I2C1_SCL/USART1_TX)
SYSCLK: IC8.12 (P31/TI03/TO03/INTP4/PCLBUZ0/UVBUSEN0), U$1.P$5 (PH0-OSC_IN/OSC_IN)
TX_FOR_STM: CON7.1, U$1.P$16 (PA2/TIM2_CH3/TIM5_CH3/TIM9_CH1/I2S2_CKI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)
USART1_RX: IC8.16 (P51/INTP2/SO00/TXD0/TOOLTXD/(TI01)/(TO0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), U$1.P$43 (PA10/TIM1_CH3/SPI5_MOSI/I2S5_SD/USART1_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)
USART1_TX: IC8.15 (P50/INTP1/SI00/RXD0/TOOLRXD/SDA00/(TI02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), U$1.P$42 (PA9/TIM1_CH2/I2C3_SMBA/USART1_TX/USB_FS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)
VCC: CON27.4 (VCC)

Notes on the sheet:
5Vトレラントのピンを探そう。 ENC*2 ADC*1
リミスイ
測距GP2Y0A21YK0F
エンコーダE6A2-CW3C 500P/R 0.5M
プルアップ抵抗
ノイズ対策RC遅延回路
パルス波再生シュミットトリガインバータ
5Vトレラントに注意
5Vトレラント PA1-15 PB0-15 PC0-12 PD0-15
NOかNCに注意！
Arduino用USART2
ENC TIM2(CH1,CH2) MD TIM5(CH1)

Board: 2 copper layers, 90.0 x 43.0 mm, 52 parts (35 on the bottom side), 38 nets.

Other parts of the board:
U$2, U$3, U$4, U$5: HOLE_3.2

## Commit log

2018-01-27 Output for board master
2018-01-30 minor change
